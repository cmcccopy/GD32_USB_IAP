# IAR project iap(msc).ewp, settings and files
configuration GD32F450I(USB_FS) (ARM, debug)
  General.OGChipSelectEditMenu: GD32F450xG GD GD32F450xG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32F450; USE_SPI_FLASH
  ICCARM.CCIncludePath2: ..\inc\GD32F4XX; ..\..\..\Firmware\CMSIS\CM4; ..\..\..\Firmware\CMSIS\GD\GD32F4xx\Include; ..\..\..\Firmware\GD_Firmware\GD32F4xx_standard_peripheral\Include; ..\..\..\Firmware\GD_usbfs_driver\GD32F4XX\Include; ..\..\..\Firmware\Board\GD32F4XX; ..\..\..\Third_Party\fat_fs\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: iap(msc).srec
  ILINK.IlinkOutputFile: iap(msc).hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F450xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32E103V(USB_FS) (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32E103xB GD GD32E103xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32E10X; GD32E103V_EVAL; USE_SPI_FLASH
  ICCARM.CCIncludePath2: ..\inc\GD32E10X; ..\..\..\Firmware\CMSIS\CM4; ..\..\..\Firmware\CMSIS\GD\GD32E10x\Include; ..\..\..\Firmware\GD_Firmware\GD32E10x_standard_peripheral\Include; ..\..\..\Firmware\GD_usbfs_driver\GD32E10X\Include; ..\..\..\Firmware\Board\GD32E10X; ..\..\..\Third_Party\fat_fs\inc
configuration GD32F107C(USB_FS) (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F107xC GD GD32F107xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32F10X_CL; USE_SPI_FLASH
  ICCARM.CCIncludePath2: ..\inc\GD32F10X; ..\..\..\Firmware\CMSIS\CM3; ..\..\..\Firmware\CMSIS\GD\GD32F10x\Include; ..\..\..\Firmware\GD_Firmware\GD32F10x_standard_peripheral\Include; ..\..\..\Firmware\GD_usbfs_driver\GD32F10X\Include; ..\..\..\Firmware\Board\GD32F10X; ..\..\..\Third_Party\fat_fs\inc
  OBJCOPY.OOCOutputFile: HID_Keyboard.srec
configuration GD32F207I(USB_FS) (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F20xxK GD GD32F20xxK
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32F20X_CL; USE_SPI_FLASH
  ICCARM.CCIncludePath2: ..\inc\GD32F20X; ..\..\..\Firmware\CMSIS\CM3; ..\..\..\Firmware\CMSIS\GD\GD32F20x\Include; ..\..\..\Firmware\GD_Firmware\GD32F20x_standard_peripheral\Include; ..\..\..\Firmware\GD_usbfs_driver\GD32F20X\Include; ..\..\..\Firmware\Board\GD32F20X; ..\..\..\Third_Party\fat_fs\inc
  OBJCOPY.OOCOutputFile: HID_Keyboard.srec
configuration GD32F307C(USB_FS) (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F307xC GD GD32F307xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32F30X_CL; USE_SPI_FLASH
  ICCARM.CCIncludePath2: ..\inc\GD32F30X; ..\..\..\Firmware\CMSIS\CM4; ..\..\..\Firmware\CMSIS\GD\GD32F30x\Include; ..\..\..\Firmware\GD_Firmware\GD32F30x_standard_peripheral\Include; ..\..\..\Firmware\GD_usbfs_driver\GD32F30X\Include; ..\..\..\Firmware\Board\GD32F30X; ..\..\..\Third_Party\fat_fs\inc
  OBJCOPY.OOCOutputFile: HID_Keyboard.srec
configuration GD32F350R(USB_FS) (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F350xB GD GD32F350xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32F350; USE_INTERNAL_FLASH
  ICCARM.CCIncludePath2: ..\inc\GD32F3X0; ..\..\..\Firmware\CMSIS\CM4; ..\..\..\Firmware\CMSIS\GD\GD32F3x0\Include; ..\..\..\Firmware\GD_Firmware\GD32F3x0_standard_peripheral\Include; ..\..\..\Firmware\GD_usbfs_driver\GD32F3X0\Include; ..\..\..\Firmware\Board\GD32F3X0; ..\..\..\Third_Party\fat_fs\inc
  OBJCOPY.OOCOutputFile: HID_Keyboard.srec
configuration GD32F403Z(USB_FS) (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F403xE GD GD32F403xE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32F403; USE_SPI_FLASH
  ICCARM.CCIncludePath2: ..\inc\GD32F403; ..\..\..\Firmware\CMSIS\CM4; ..\..\..\Firmware\CMSIS\GD\GD32F403\Include; ..\..\..\Firmware\GD_Firmware\GD32F403_standard_peripheral\Include; ..\..\..\Firmware\GD_usbfs_driver\GD32F403\Include; ..\..\..\Firmware\Board\GD32F403; ..\..\..\Third_Party\fat_fs\inc
  OBJCOPY.OOCOutputFile: HID_Keyboard.srec
  group Application_E103
    ../src/GD32E10X/: gd25qxx.c gd32e10x_it.c iap.c main.c usb_delay.c usbd_bbb_scsi.c usbd_msc_core.c usbd_stroage_access.c
  group Application_F107
    ../src/GD32F10X/: app.c gd25qxx.c gd32f10x_it.c iap.c usb_delay.c usbd_bbb_scsi.c usbd_msc_core.c usbd_stroage_access.c
  group Application_F207
    ../src/GD32F20X/: app.c gd25qxx.c gd32f20x_it.c iap.c usb_delay.c usbd_bbb_scsi.c usbd_msc_core.c usbd_stroage_access.c
  group Application_F307
    ../src/GD32F30X/: gd25qxx.c gd32f30x_it.c iap.c main.c usb_delay.c usbd_bbb_scsi.c usbd_msc_core.c usbd_stroage_access.c
  group Application_F3X0
    ../src/GD32F3X0/: gd32f3x0_it.c iap.c main.c usb_delay.c usbd_bbb_scsi.c usbd_msc_core.c usbd_stroage_access.c
  group Application_F403
    ../src/GD32F403/: gd25qxx.c gd32f403_it.c iap.c main.c usb_delay.c usbd_bbb_scsi.c usbd_msc_core.c usbd_stroage_access.c
  group Application_F450
    ../src/GD32F4XX/: gd25qxx.c gd32f4xx_it.c iap.c main.c usb_delay.c usbd_bbb_scsi.c usbd_msc_core.c usbd_stroage_access.c
  group CMSIS
    ../../../Firmware/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
    ../../../Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    ../../../Firmware/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
    ../../../Firmware/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
    ../../../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../../../Firmware/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
    ../../../Firmware/CMSIS/GD/GD32F403/Source/: system_gd32f403.c
    ../../../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Doc
    ../: readme.txt
  group Fatfs
    ../../../Third_Party/fat_fs/src/: diskio.c ff.c
  group GD32E10x_EVAL
    ../../../Firmware/Board/GD32E10X/: gd32e10x_eval.c
  group GD32E10x_Peripherals
    ../../../Firmware/GD_Firmware/GD32E10x_standard_peripheral/Source/: gd32e10x_adc.c gd32e10x_bkp.c gd32e10x_can.c gd32e10x_crc.c gd32e10x_ctc.c gd32e10x_dac.c gd32e10x_dbg.c gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_fwdgt.c gd32e10x_gpio.c gd32e10x_i2c.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_rtc.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_wwdgt.c
  group GD32F10x_EVAL
    ../../../Firmware/Board/GD32F10X/: gd32f10x_eval.c
  group GD32F10x_Peripherals
    ../../../Firmware/GD_Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group GD32F20x_EVAL
    ../../../Firmware/Board/GD32F20X/: gd32f207i_eval.c
  group GD32F20x_Peripherals
    ../../../Firmware/GD_Firmware/GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
  group GD32F30x_EVAL
    ../../../Firmware/Board/GD32F30X/: gd32f307c_eval.c
  group GD32F30x_Peripherals
    ../../../Firmware/GD_Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group GD32F3x0_EVAL
    ../../../Firmware/Board/GD32F3X0/: gd32f350r_eval.c
  group GD32F3x0_Peripherals
    ../../../Firmware/GD_Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group GD32F403_EVAL
    ../../../Firmware/Board/GD32F403/: gd32f403z_eval.c
  group GD32F403_Peripherals
    ../../../Firmware/GD_Firmware/GD32F403_standard_peripheral/Source/: gd32f403_adc.c gd32f403_bkp.c gd32f403_can.c gd32f403_crc.c gd32f403_ctc.c gd32f403_dac.c gd32f403_dbg.c gd32f403_dma.c gd32f403_exmc.c gd32f403_exti.c gd32f403_fmc.c gd32f403_fwdgt.c gd32f403_gpio.c gd32f403_i2c.c gd32f403_misc.c gd32f403_pmu.c gd32f403_rcu.c gd32f403_rtc.c gd32f403_sdio.c gd32f403_spi.c gd32f403_timer.c gd32f403_usart.c gd32f403_wwdgt.c
  group GD32F4xx_EVAL
    ../../../Firmware/Board/GD32F4XX/: gd32f450i_eval.c
  group GD32F4xx_Peripherals
    ../../../Firmware/GD_Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group GDE10X_usbfs_driver
    ../../../Firmware/GD_usbfs_driver/GD32E10X/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group GDF10X_usbfs_driver
    ../../../Firmware/GD_usbfs_driver/GD32F10X/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group GDF20X_usbfs_driver
    ../../../Firmware/GD_usbfs_driver/GD32F20X/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group GDF30X_usbfs_driver
    ../../../Firmware/GD_usbfs_driver/GD32F30X/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group GDF3X0_usbfs_driver
    ../../../Firmware/GD_usbfs_driver/GD32F3X0/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group GDF403_usbfs_driver
    ../../../Firmware/GD_usbfs_driver/GD32F403/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group GDF4XX_usbfs_driver
    ../../../Firmware/GD_usbfs_driver/GD32F4XX/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group Startup
    ../../../Firmware/CMSIS/GD/GD32E10x/Source/IAR/: startup_gd32e10x.s
    ../../../Firmware/CMSIS/GD/GD32F10x/Source/IAR/: startup_gd32f10x_cl.s
    ../../../Firmware/CMSIS/GD/GD32F1x0/Source/IAR/: startup_gd32f1x0.s
    ../../../Firmware/CMSIS/GD/GD32F20x/Source/IAR/: startup_gd32f20x_cl.s
    ../../../Firmware/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_cl.s
    ../../../Firmware/CMSIS/GD/GD32F3x0/Source/IAR/: startup_gd32f3x0.s
    ../../../Firmware/CMSIS/GD/GD32F403/Source/IAR/: startup_gd32f403.s
    ../../../Firmware/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f450.s
