# Keil uVision project iap(msc).uvprojx, settings and files
target GD32F450I(USB_FS) (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F450IG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: iap +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER GD32F450 USE_USBFS USE_SPI_FLASH
  c misc: --c99
  c include: ..\inc\GD32F4XX;..\..\..\Firmware\CMSIS\CM4;..\..\..\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\..\Firmware\GD_Firmware\GD32F4xx_standard_peripheral\Include;..\..\..\Firmware\GD_usbfs_driver\GD32F4XX\Include;..\..\..\Firmware\Board\GD32F4XX;..\..\..\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application_F450
    ../src/GD32F4XX/: gd32f4xx_it.c usb_delay.c gd25qxx.c iap.c main.c usbd_bbb_scsi.c usbd_msc_core.c usbd_stroage_access.c
  group CMSIS
    ../../../Firmware/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
    ../../../Firmware/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
    ../../../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../../../Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    ../../../Firmware/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
    ../../../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../../../Firmware/CMSIS/GD/GD32F403/Source/: system_gd32f403.c
  group GD32F4xx_Peripherals
    ../../../Firmware/GD_Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group GD32F4xx_EVAL
    ../../../Firmware/Board/GD32F4XX/: gd32f450i_eval.c
  group Startup
    ../../../Firmware/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
    ../../../Firmware/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
    ../../../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450.s
    ../../../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s
    ../../../Firmware/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
    ../../../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
    ../../../Firmware/CMSIS/GD/GD32F403/Source/ARM/: startup_gd32f403.s
  group GDF4XX_usbfs_driver
    ../../../Firmware/GD_usbfs_driver/GD32F4XX/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group Fatfs
    ../../../Third_Party/fat_fs/src/: diskio.c ff.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.1.1
